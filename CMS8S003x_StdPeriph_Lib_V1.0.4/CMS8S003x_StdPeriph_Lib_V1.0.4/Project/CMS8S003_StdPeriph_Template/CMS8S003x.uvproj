# Keil uVision project CMS8S003x.uvproj, settings and files
target CMSemicon (MCS-51)
  device: CMS51F003 CMS
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0x0000-0x03FF) CLOCK(50000000) MOD517AU MODDP2
  output: CMS8S003x
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Libraries\CMS8S003_StdPeriph_Driver\inc
  group Startup
    ./: STARTUP.A51
  group StdPeriph_Lib
    ../../Libraries/CMS8S003_StdPeriph_Driver/src/: cms8s003x_adc.c cms8s003x_beep.c cms8s003x_clk.c cms8s003x_comp.c cms8s003x_epwm.c cms8s003x_flash.c cms8s003x_gpio.c cms8s003x_iic.c cms8s003x_itc.c cms8s003x_op.c cms8s003x_spi.c cms8s003x_syscon.c cms8s003x_tim01.c cms8s003x_tim2.c cms8s003x_tim34.c cms8s003x_uart.c cms8s003x_wdg.c
  group User
    ./: main.c
